Commit message: Completed falling cube example, started r2d2

File: cube.urdf (robot description, URDF)
Before this commit: robot cube.urdf, 1 links, 0 joints
Links:
- link baseLink: mass .1 -> None; geometry collision box size=1 1 1; visual mesh filename=cube.obj scale=1 1 1
